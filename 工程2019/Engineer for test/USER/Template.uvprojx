# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\USER;..\CMSIS;..\FWlib\inc;..\FWlib\src;..\Mylib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../FWlib/src/: stm32f4xx_syscfg.c
  group FWlib
    ../FWlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c
  group Mylib
    ../Mylib/: algorithmOfCRC.c can1.c can2.c usart3.c uart5.c led.c pid.c state.c float2byte.c delay.c chassis_task.c track_task.c solenoid_task.c
